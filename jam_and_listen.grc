options:
  parameters:
    generate_options: qt_gui
    id: jam_and_listen
    output_language: python
    title: jam_and_listen
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 433.903e6
  states: {}
- name: window_freq
  id: variable
  parameters:
    value: 433.910e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\andre\Desktop\prueba_apertura.dll
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\andre\Desktop\jam1.dll
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '8'
    type: complex
  states: {}
- name: channels_amp_bal_0
  id: channels_amp_bal
  parameters:
    alpha: '20'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '30'
    freq0: window_freq
    gain0: '0'
    if_gain0: '3000'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: target_freq
    fftsize: '1024'
    name: '"Raw_key"'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: target_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_amp_bal_0, '0']
- [channels_amp_bal_0, '0', osmosdr_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
