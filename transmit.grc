options:
  parameters:
    author: andres
    generate_options: qt_gui
    id: transmit
    output_language: python
    title: transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 433.903e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\andre\Desktop\captured_key_1.dll
    repeat: 'True'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: target_freq
    gain0: '0'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: target_freq
    fftsize: '1024'
    type: complex
    update_time: '0.0010'
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
